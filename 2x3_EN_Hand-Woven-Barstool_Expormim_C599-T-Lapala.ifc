Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2020-05-21T17:31:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - IU alternativa 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 21 17:31:10 2020 * Host: DESKTOP-5OV4RIT * Database: C:\Users\34629\AppData\Local\Temp\{1F8A7145-1C22-4CED-B296-92CE5025D46D}\ifc * Database version: 5507 * Database creation date: Thu May 21 17:31:10 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 21 17:31:10 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 21 17:31:10 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 13, 9643; RefLongitude: -3, -42, -20, -772056; RefElevation: 0 mm
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: 0001

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Restricciones(Type) - Altura base: Punto base del proyecto
Otros(Type) - Categoría: Niveles; Nombre de familia: Nivel
Gráficos(Type) - Color: 0; Grosor de línea: 1; Patrón de línea: Sólido; Símbolo: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Símbolo en extremo 1 por defecto: no; Símbolo en extremo 2 por defecto: yes
Datos de identidad(Type) - Nombre de tipo: Extremo inicial 8 mm
Cotas - Altura de cálculo: 0 mm
Datos de identidad - Estructura: no; Nombre: Nivel 1; Planta de edificio: yes
Otros - Categoría: Niveles; Familia: Nivel: Extremo inicial 8 mm; Familia y tipo: Nivel: Extremo inicial 8 mm; ID de tipo: Nivel: Extremo inicial 8 mm; Tipo: Nivel: Extremo inicial 8 mm
Restricciones - Alzado: 0 mm

# IfcFurnishingElement: 0,51 x 0,52 x 1,01 m / 20.5" x 20" x 39.75", 2019_EN_Hand-Woven-Barstool_Expormim_C599T-Lapala:0,51 x 0,52 x 1,01 m / 20.5" x 20" x 39.75":144732
In: Nivel 1
Type - ElementType: 0,51 x 0,52 x 1,01 m / 20.5" x 20" x 39.75"; Material: Stainless steel, Stainless steel - Mesh 3, Stainless steel - Mesh4
Type - Cotas - Height: 1010 mm; Length: 510 mm; SeatHeight: 750 mm; Weight: 7; Width: 520 mm
Type - Datos - System: Furniture
Type - Datos de identidad - Author: Bimetica Parametric Design Services SL; BIMEelementExpiryDate: 20/05/2021; BIMElementIssueDate: 20/05/2020; Bimetica: www.bimetica.com; BimeticaProductProfileURL: https://bimetica.com/es/bim-object-expormim-lapala-barstool-lievore-altherr-molina-5786.html; BIM Support: https://bimsupport.info/es/fabricantes/expormim-bim/; Comentarios de tipo: Unique and exclusive pieces created by world-renowned designers with an outstanding career and much experience. In an effort to recover the characteristic braided chair so typical of the Mediterranean, Expormim reedits the seating collection Lapala, a classic by Lievore Altherr Molina Studio. “Her curves and gentle shape keep the sober, light and versatile character of the original design. This update brings a significant increase in comfort through its improved ergonomics as well as a higher performance to weather conditions due to the fact it is woven with nautical rope on a painted stainless steel frame.”; CountryOfSale: AUSTRALIA, BELGIUM, CANADA, FRANCE, GERMANY, ISRAEL, ITALY, JAMAICA, JAPAN, JORDAN, KAZAKHSTAN, KENYA, KOREA, KOSOVO, KUWAIT, LATVIA, LEBANON, LIBYA, LITHUANIA, MACEDONIA, MALAYSIA, MALT, MOROCCO, MAURITIUS, MEXICO, MIDDLE EAST, NICARAGUA, NORWAY, NEW ZEALAND, PANAMA, PERU, POLAND, PORTUGAL, PUERTO RICO, QUATAR, UNITED KINGDOM, USA, REP.OF MALDIVES, REPUBLIC OF YEMEN, CZECH REPUBLIC, REPUBLIC OF SAN MARINO, DOMINICAN REPUBLIC, ROMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPORE, SOUTH AFRICA, SPAIN, SRI LANKA, SWEDEN, SWITZERLAND, SULTANATE OF OMAN, THAILAND, TAIWAN, TUNISIA, TURKEY, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; Descripción: Hand-woven barstool; Designer: Lievore Altherr Molina; Fabricante: EXPORMIM S.A.; IsExternal: yes; LicenseNumber: XXX-XXXX4564; Modelo: C599 T hand-woven barstool; Nombre de tipo: 0,51 x 0,52 x 1,01 m / 20.5" x 20" x 39.75"; Número OmniClass: 23.40.20.00; Owner: EXPORMIM S.A.; ProductionYear: 2015; ProductURL: https://www.expormim.com/product_collections/outdoor/product_familys/lapala/; SalesRepresentativeContact: export@expormim.com; Series: Lapala; TechnicalInformation: https://downloads.expormim.com/direct/VqzDkg6Llp/folder/711; TechnicalSupportContact: expormim@bimsupport.info; TelephoneContact: 0034 962 295 144; Título OmniClass: General Furniture and Specialties; URL: https://www.expormim.com; Version: RVT-2019
Type - Materiales y acabados - Collection: outdoor; Finish: Barstool made of stainless steel tube. Hand-woven seat and backrest with high resistance rope 7 mm/0.27” thick. Legs made of lacquered stainless steel tube. Stackable.; HousingMaterial: Stainless steel; PrimaryColor: explore expormim outdoor catalogue
Type - Otros - Categoría: Mobiliario; Nombre de familia: 2019_EN_Hand-Woven-Barstool_Expormim_C599T-Lapala
Pset_ManufacturerTypeInformation - Manufacturer: EXPORMIM S.A.; ProductionYear: 2015
Cantidades de mobiliario - Descripción de unidad: 2019_EN_Hand-Woven-Barstool_Expormim_C599T-Lapala: 0,51 x 0,52 x 1,01 m / 20.5" x 20" x 39.75"; Tipo: 2019_EN_Hand-Woven-Barstool_Expormim_C599T-Lapala: 0,51 x 0,52 x 1,01 m / 20.5" x 20" x 39.75"; Descripción: Hand-woven barstool; Fabricante: EXPORMIM S.A.; Modelo: C599 T hand-woven barstool; URL: https://www.expormim.com; Comentarios: Unique and exclusive pieces created by world-renowned designers with an outstanding career and much experience. In an effort to recover the characteristic braided chair so typical of the Mediterranean, Expormim reedits the seating collection Lapala, a classic by Lievore Altherr Molina Studio. “Her curves and gentle shape keep the sober, light and versatile character of the original design. This update brings a significant increase in comfort through its improved ergonomics as well as a higher performance to weather conditions due to the fact it is woven with nautical rope on a painted stainless steel frame.”
Cotas - Área: 0.383518 m2; Volumen: 0.0013653 m3
Otros - Familia: 2019_EN_Hand-Woven-Barstool_Expormim_C599T-Lapala: 0,51 x 0,52 x 1,01 m / 20.5" x 20" x 39.75"; Familia y tipo: 2019_EN_Hand-Woven-Barstool_Expormim_C599T-Lapala: 0,51 x 0,52 x 1,01 m / 20.5" x 20" x 39.75"; ID de tipo: 2019_EN_Hand-Woven-Barstool_Expormim_C599T-Lapala: 0,51 x 0,52 x 1,01 m / 20.5" x 20" x 39.75"; Tipo: 2019_EN_Hand-Woven-Barstool_Expormim_C599T-Lapala: 0,51 x 0,52 x 1,01 m / 20.5" x 20" x 39.75"
Proceso por fases - Fase de creación: Fase 1
Restricciones - Anfitrión: Nivel : Nivel 1; Desfase: 0 mm; Nivel: Nivel: Nivel 1; Se mueve con elementos cercanos: no
